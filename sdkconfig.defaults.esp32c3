## sdkconfig.defaults.esp32c3
```kconfig
CONFIG_BLINK_LED_STRIP=y
CONFIG_ESP_WIFI_ENABLED=y
CONFIG_ESP_WIFI_SOFTAP_SUPPORT=y
```
